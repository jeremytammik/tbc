Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: C:\Users\David\AppData\Local\Temp\ifc001.ifc
Time: 2016-2-12T9:40:45
Author: David
Organization: *DEMONSTRATION LICENSE-FOR EVALUATION PURPOSES ONLY*
Written by: Notepad
Made in: Design Master Electrical 8.4 Early Release 5 (16218)

# IfcBuilding
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
